# Keil uVision project Proj2.uvprojx, settings and files
target Proj2 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  cpu: CPUTYPE("Cortex-M3")
  output: Proj2
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DTARGET_LPCTarget -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DMBED_BUILD_TIMESTAMP=1495005554.02 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; C12832; EthernetInterface; EthernetInterface/Socket; EthernetInterface/lwip; EthernetInterface/lwip/netif; EthernetInterface/lwip/netif/ppp; EthernetInterface/lwip/api; EthernetInterface/lwip/core; EthernetInterface/lwip/core/snmp; EthernetInterface/lwip/core/ipv4; EthernetInterface/lwip/include; EthernetInterface/lwip/include/netif; EthernetInterface/lwip/include/lwip; EthernetInterface/lwip/include/ipv4; EthernetInterface/lwip/include/ipv4/lwip; EthernetInterface/lwip-sys; EthernetInterface/lwip-sys/arch; EthernetInterface/lwip-eth; EthernetInterface/lwip-eth/arch; EthernetInterface/lwip-eth/arch/TARGET_NXP; LM75B; mbed-rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM; mbed-rtos/rtos; picojson; RemoteIR; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group C12832
    C12832/: C12832.cpp C12832.h GraphicsDisplay.cpp GraphicsDisplay.h Small_7.h TextDisplay.cpp TextDisplay.h
  group EthernetInterface
    EthernetInterface/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
    EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    EthernetInterface/lwip/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h
    EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    EthernetInterface/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
    EthernetInterface/lwip-sys/arch/: cc.h checksum.c memcpy.c perf.h sys_arch.c sys_arch.h
    EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    EthernetInterface/Socket/: Endpoint.cpp Endpoint.h Socket.cpp Socket.h TCPSocketConnection.cpp TCPSocketConnection.h TCPSocketServer.cpp TCPSocketServer.h UDPSocket.cpp UDPSocket.h
    EthernetInterface/: eth_arch.h EthernetInterface.cpp EthernetInterface.h
    EthernetInterface/lwip/netif/: etharp.c ethernetif.c slipif.c
    EthernetInterface/lwip/include/netif/: etharp.h ppp_oe.h slipif.h
    EthernetInterface/lwip-eth/arch/TARGET_NXP/: lpc17_emac.c lpc17xx_emac.h lpc_emac_config.h lpc_phy.h lpc_phy_dp83848.c lwipopts_conf.h
    EthernetInterface/lwip/: lwipopts.h
  group LM75B
    LM75B/: LM75B.cpp LM75B.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o ethernet_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o sys.o system_LPC17xx.o us_ticker.o
    mbed/TARGET_LPC1768/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis.h cmsis_nvic.h LPC17xx.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    mbed/: mbed.h
    mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
  group mbed-rtos
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group picojson
    picojson/: picojson.h
  group Proj2
    ./: Communication.cpp Communication.h Controller.cpp Controller.h JSONParser.cpp JSONParser.h LCD.cpp LCD.h LightCommunication.cpp LightCommunication.h main.cpp mbed_config.h
  group RemoteIR
    RemoteIR/: ReceiverIR.cpp ReceiverIR.h RemoteIR.h TransmitterIR.cpp TransmitterIR.h
